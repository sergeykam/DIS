# IAR project DIS_matrix.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration maket (AVR, debug)
  as the first configuration, except:
  General.LCHeapSize: 0
  General.GenDeviceSelectMenu: m16 ATmega16
  ICCAVR.newCCIncludePaths: ..\__hdr
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm16.xcl
configuration plata (AVR, debug)
  as the first configuration, except:
  General.LCHeapSize: 0
  General.GenDeviceSelectMenu: m168pa ATmega168PA
  ICCAVR.newCCIncludePaths: ..\__hdr
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168pa.xcl
  group (top)
    ../__src/: DIS_matrix.c
  group API
    ../../__API/: DIS_API.c SPI_API.c TIMER0_HW_API.c UART_API.c WIFI_API.c
