<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\DIS_matrix\_IAR\DIS_matrix.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\test_DIS\_IAR\test_DIS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\test_wifi\_IAR\test_wifi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


